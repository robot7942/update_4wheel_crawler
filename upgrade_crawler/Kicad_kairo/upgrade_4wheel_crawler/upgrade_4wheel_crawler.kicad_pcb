# Repository robot7942/update_4wheel_crawler

## KiCad design upgrade_crawler/Kicad_kairo/upgrade_4wheel_crawler/upgrade_4wheel_crawler.kicad_pcb

Parts:
C1, C4, C5, C7, C9, C12, C14, C16: 47μF; CP_Radial_D10.0mm_P5.00mm
C2, C3, C6, C8, C10, C11, C13, C15, C17, C20, C21, C22: 0.1μF; C_0603_1608Metric
C18, C19: 22pF; C_0603_1608Metric
D1: P4KE15A; D_DO-34_SOD68_P7.62mm_Horizontal; PARTREV N2104
D2, D3: 1N5819; D_DO-41_SOD81_P10.16mm_Horizontal
D4, D5, D6, D7, D8: LED; D_0603_1608Metric
F1: 3557-15_5A; FUSE_3557-15; PARTREV D
F2: MF-R050_0.5A; Fuse_Bourns_MF-RG300
J1: Conn_01x02; AMASS_XT60PW-M_1x02_P7.20mm_Horizontal
J2: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
J3: Conn_swing_lock_FL; PinHeader_1x03_P2.54mm_Vertical
J4: Conn_swing_lock_FR; PinHeader_1x03_P2.54mm_Vertical
J5: Conn_swing_lock_BL; PinHeader_1x03_P2.54mm_Vertical
J6: Conn_swing_lock_BR; PinHeader_1x03_P2.54mm_Vertical
J7: Conn_flipper_front; PinHeader_1x03_P2.54mm_Vertical
J8: Conn_flipper_back; PinHeader_1x03_P2.54mm_Vertical
J9: Conn_PWM6; PinHeader_1x03_P2.54mm_Vertical
J10: Conn_PWM7; PinHeader_1x03_P2.54mm_Vertical
J11: Conn_PWM8; PinHeader_1x03_P2.54mm_Vertical
J12: Conn_PWM9; PinHeader_1x03_P2.54mm_Vertical
J13: Conn_PWM10; PinHeader_1x03_P2.54mm_Vertical
J14: Conn_PWM11; PinHeader_1x03_P2.54mm_Vertical
J15: Conn_PWM12; PinHeader_1x03_P2.54mm_Vertical
J16: Conn_PWM13; PinHeader_1x03_P2.54mm_Vertical
J17: Conn_PWM14; PinHeader_1x03_P2.54mm_Vertical
J18: Conn_PWM15; PinHeader_1x03_P2.54mm_Vertical
J19: Conn_CAN_IN; JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal
J20: Conn_CAN_OUT; JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal
J21: Conn_wheel_FL; JST_XH_S6B-XH-A_1x06_P2.50mm_Horizontal
J22: Conn_wheel_FR; JST_XH_S6B-XH-A_1x06_P2.50mm_Horizontal
J23: Conn_wheel_BL; JST_XH_S6B-XH-A_1x06_P2.50mm_Horizontal
J24: Conn_wheel_BR; JST_XH_S6B-XH-A_1x06_P2.50mm_Horizontal
J25: Conn_BNO055; PinSocket_1x04_P2.54mm_Vertical
J26, J27, J28, J29: Conn_01x01; PinHeader_1x01_P2.54mm_Vertical
Q1: MTB060P06I3; Manufacturer_Part_Number MTB060P06I3
Q2, Q3: 2SC2712; SC-59_Handsoldering
R1: 100kΩ; Resister_1_4W
R2: 33kΩ; Resister_1_4W
R3, R4, R5, R6, R7: 10kΩ; Resister_1_4W
R8, R9, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R26, R27, R28, R29, R30, R33, R34, R35, R36, R37, R38, R39, R40: 10kΩ; R_0603_1608Metric
R25: 120Ω; R_0603_1608Metric
R31, R32: 5.1kΩ; R_0603_1608Metric
SW1: SW_power; Switch_Slide_11.6x4mm_EG1218
SW2: SW_CAN_end; Switch_Slide_11.6x4mm_EG1218
SW3, SW4: EN; SW_ADTS_6P2X6P2_APM
U1: YAAJ_DCDC_StepDown_LM2596
U2: NJM7805FA-ND; NJR-TO-220F-3_NJR
U3: LM2940T-3.3; TO254P470X1016X2222-3P; Manufacturer_Part_Number LM2940T-5.0; Mouser Part Number 926-LM2940T-50
U4: ADS1015IDGST; MSOP-10_W3mm; MPN ADS1015IDGST; Digi-Key_PN 296-25227-1-ND
U5: PCA9685PW_112; TSSOP-28_W4.40mm; MPN PCA9685PW,112; Digi-Key_PN 568-8366-5-ND
U6, U7, U8, U9: TB67H450FNG_EL; SOIC127P599X175-9N; PARTREV 3.0
U10: ESP32-WROOM-32E; ESP32-WROOM-32D
U11: CH340G; SOIC-16_3.9x9.9mm_P1.27mm
U12: ATA6561-GAQW-N; JEITA_SOIC-8_3.9x4.9mm_P1.27mm
Y1: FA-238V_12.0000MB-K3; XTAL_FA-238V_12.0000MB-K3; PARTREV N/A
Z1: GDZJ15C; D_DO-34_SOD68_P7.62mm_Horizontal; Manufacturer_Part_Number GDZJ15C

Connections:
Battery_+: F1.1_1, F1.1_2, J1.2
Battery_-: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, D1.2, J1.1, J2.A1 (GND), J2.A12 (GND), J2.B1 (GND), J2.B12 (GND), J2.SH (SHIELD), J3.3, J4.3, J5.3, J6.3, J7.3, J8.3, J9.3, J10.3, J11.3, J12.3, J13.3, J14.3, J15.3, J16.3, J17.3, J18.3, J19.4, J20.4, J21.5, J22.5, J23.5, J24.5, J25.2, R1.2, R3.2, R5.2, R7.2, R11.2, R12.2, R13.2, R14.2, R15.2, R16.2, R17.2, R18.2, R26.2, R27.2, R28.2, R29.2, R30.2, R31.2, R32.2, SW3.2, SW4.2, U1.2 (GND), U1.3 (GND), U2.2 (EPAD), U3.2 (GND), U4.1 (ADDR), U4.3 (GND), U5.1 (A0), U5.2 (A1), U5.3 (A2), U5.4 (A3), U5.5 (A4), U5.14 (VSS), U5.24 (A5), U5.25 (EXTCLK), U6.1 (GND), U6.7 (RS), U6.9 (GND__1), U7.1 (GND), U7.7 (RS), U7.9 (GND__1), U8.1 (GND), U8.7 (RS), U8.9 (GND__1), U9.1 (GND), U9.7 (RS), U9.9 (GND__1), U10.1 (GND), U10.15 (GND), U10.38 (GND), U10.39 (GND), U11.1 (GND), U11.15 (R232), U12.2 (GND), U12.8 (STBY), Y1.2 (GND), Y1.4 (GND__1)
CAN_BUS_H: J19.2, J20.2, SW2.2 (B), U12.7 (CANH)
CAN_BUS_L: J19.3, J20.3, R25.2, U12.6 (CANL)
CAN_RX: U10.29 (IO5), U12.4 (RXD)
CAN_TX: U10.26 (IO4), U12.1 (TXD)
DC_wheel_BL_A: J23.1, U8.6 (OUT1)
DC_wheel_BL_B: J23.6, U8.8 (OUT2)
DC_wheel_BR_A: J24.1, U9.6 (OUT1)
DC_wheel_BR_B: J24.6, U9.8 (OUT2)
DC_wheel_FL_A: J21.1, U6.6 (OUT1)
DC_wheel_FL_B: J21.6, U6.8 (OUT2)
DC_wheel_FR_A: J22.1, U7.6 (OUT1)
DC_wheel_FR_B: J22.6, U7.8 (OUT2)
unnamed: C4.1, D2.1 (K), D3.1 (K), U3.1 (IN)
unnamed: D4.1 (K), R26.1
unnamed: D5.1 (K), R27.1
unnamed: D6.1 (K), R28.1
unnamed: D7.1 (K), R29.1
unnamed: D8.1 (K), R30.1
unnamed: F2.2, J2.A4 (VBUS), J2.A9 (VBUS), J2.B4 (VBUS), J2.B9 (VBUS)
unnamed: J2.A5 (CC1), R31.1
unnamed: J2.B5 (CC2), R32.1
unnamed: Q1.1 (G), R1.1, Z1.2
unnamed: Q2.1 (B), R23.2
unnamed: Q2.2 (E), R24.1, U11.14 (~RTS)
unnamed: Q3.1 (B), R24.2
unnamed: Q3.2 (E), R23.1, U11.13 (~DTR)
unnamed: R25.1, SW2.3 (C)
unnamed: R2.2, R3.1, U4.4 (AIN0)
unnamed: R4.2, R5.1, U4.5 (AIN1)
unnamed: R6.2, R7.1, U4.6 (AIN2)
unnamed: C18.1, U11.7 (XI), Y1.1
unnamed: C19.1, U11.8 (XO), Y1.3
PCA_output_enable: R9.2, U5.23 (~OE), U10.23 (IO15)
SCL: J25.4, R21.2, U4.10 (SCL), U5.26 (SCL), U10.36 (IO22)
SDA: J25.3, R20.2, U4.9 (SDA), U5.27 (SDA), U10.33 (IO21)
SW_BOOT: Q3.3 (C), R22.2, SW4.1, U10.25 (IO0)
SW_EN: C17.1, Q2.3 (C), R19.2, SW3.1, U10.3 (EN)
SW_output: C1.1, C2.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, D5.2 (A), R2.1, SW1.3 (C), U1.1 (Vin), U2.1 (EPAD), U6.5 (VM), U7.5 (VM), U8.5 (VM), U9.5 (VM)
Servo_5_output: J27.1 (Pin_1_1), R4.1, U1.4 (Vout)
Servo_flipper_back: J8.1, U5.11 (LED5)
Servo_flipper_front: J7.1, U5.10 (LED4)
Servo_swing_lock_BL: J5.1, U5.8 (LED2)
Servo_swing_lock_BR: J6.1, U5.9 (LED3)
Servo_swing_lock_FL: J3.1, U5.6 (LED0)
Servo_swing_lock_FR: J4.1, U5.7 (LED1)
UART_RX: U10.34 (RXD0/IO3), U11.2 (TXD)
UART_TX: U10.35 (TXD0/IO1), U11.3 (RXD)
USB_5V: D3.2 (A), D6.2 (A), F2.1
USB_D+: J2.A6 (D+), J2.B6 (D+), U11.5 (UD+)
USB_D-: J2.A7 (D-), J2.B7 (D-), U11.6 (UD-)
counter_reverse_output: D1.1, Q1.3 (S), SW1.2 (B), Z1.1
fuse_output: F1.2_1, F1.2_2, Q1.2 (D)
logic_3.3_output: C5.1, C6.1, C7.1, C8.1, C20.1, C22.1, D8.2 (A), J21.2, J22.2, J23.2, J24.2, J25.1, J29.1 (Pin_1_1), R8.1, R9.1, R19.1, R20.1, R21.1, R22.1, R33.1, R34.1, R35.1, R36.1, R37.1, R38.1, R39.1, R40.1, U3.3 (OUT), U4.7 (AIN3), U4.8 (VDD), U5.28 (VDD), U6.4 (VREF), U7.4 (VREF), U8.4 (VREF), U9.4 (VREF), U10.2 (VDD), U11.4 (V3), U11.16 (VCC), U12.5 (VIO)
logic_5_output: C3.1, C21.1, D2.2 (A), D7.2 (A), J3.2, J4.2, J5.2, J6.2, J7.2, J8.2, J9.2, J10.2, J11.2, J12.2, J13.2, J14.2, J15.2, J16.2, J17.2, J18.2, J19.1, J20.1, J28.1 (Pin_1_1), R6.1, U2.3 (EPAD), U12.3 (VCC)
status_LED: D4.2 (A), U10.24 (IO2)
testpad_ADS_RDY: R8.2, U4.2 (ALRT/RDY)
testpad_IO12: J26.1 (Pin_1_1), U10.14 (IO12)
testpad_pwm6: J9.1, U5.12 (LED6)
testpad_pwm7: J10.1, U5.13 (LED7)
testpad_pwm8: J11.1, U5.15 (LED8)
testpad_pwm9: J12.1, U5.16 (LED9)
testpad_pwm10: J13.1, U5.17 (LED10)
testpad_pwm11: J14.1, U5.18 (LED11)
testpad_pwm12: J15.1, U5.19 (LED12)
testpad_pwm13: J16.1, U5.20 (LED13)
testpad_pwm14: J17.1, U5.21 (LED14)
testpad_pwm15: J18.1, U5.22 (LED15)
wheel_encoder_BL_A: J23.3, R37.2, U10.37 (IO23)
wheel_encoder_BL_B: J23.4, R38.2, U10.10 (IO25)
wheel_encoder_BR_A: J24.3, R39.2, U10.11 (IO26)
wheel_encoder_BR_B: J24.4, R40.2, U10.12 (IO27)
wheel_encoder_FL_A: J21.3, R33.2, U10.6 (IO34)
wheel_encoder_FL_B: J21.4, R34.2, U10.7 (IO35)
wheel_encoder_FR_A: J22.3, R35.2, U10.4 (SENSOR_VP)
wheel_encoder_FR_B: J22.4, R36.2, U10.5 (SENSOR_VN)
wheel_input_BL_A: R15.1, U8.3 (IN1), U10.8 (IO32)
wheel_input_BL_B: R16.1, U8.2 (IN2), U10.9 (IO33)
wheel_input_BR_A: R17.1, U9.3 (IN1), U10.16 (IO13)
wheel_input_BR_B: R18.1, U9.2 (IN2), U10.13 (IO14)
wheel_input_FL_A: R11.1, U6.3 (IN1), U10.30 (IO18)
wheel_input_FL_B: R12.1, U6.2 (IN2), U10.31 (IO19)
wheel_input_FR_A: R13.1, U7.3 (IN1), U10.27 (IO16)
wheel_input_FR_B: R14.1, U7.2 (IN2), U10.28 (IO17)

Notes on the sheet:
マイコン
USBコネクタ
電圧監視
逆接保護
電源スイッチ
バッテリー出入口
テストパッド
モータードライバ
その他コネクタ
USB-UART
サーボ用最大25MHzPWM出力器
CANトランシーバ
LED
その他スイッチ

Board: 2 copper layers, 121 parts (0 on the bottom side), 85 nets, no tracks yet.
